# Keil uVision project STM32F411RE_SSL_DMA.uvprojx, settings and files
target STM32F411RE_SSL_DMA (5060960::V5.06 update 7 (build 960)::.\Arm_Compiler_5.06u7)
  device: STM32F411RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: STM32F411RE_SSL_DMA +hex
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: MBEDTLS_CONFIG_FILE=<mbedtls_config.h>,USE_HAL_DRIVER,STM32F411xE
  c include: ../Core/Inc;../CoreMarkApp/App;../CoreMarkApp;../MBEDTLS/App;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Middlewares/Third_Party/mbedTLS/include/mbedtls;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Middlewares/Third_Party/mbedTLS/include;../Drivers/CMSIS/Include;../Utilities/3rdParty/MISC;..\Middlewares\Third_Party\ioLibrary_Driver\Ethernet\W5500;..\Middlewares\Third_Party\ioLibrary_Driver\Ethernet;..\Middlewares\Third_Party\ioLibrary_Driver\Internet\DHCP
  asm include: ../Core/Inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Application/MDK-ARM
    ./: startup_stm32f411xe.s
  group Application/User/Core
    ../Core/Src/: main.c freertos.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c w5x00_spi.c w5x00_tcp_client_over_ssl.c
  group Application/User/CoreMarkApp/App
    ../CoreMarkApp/App/: app_coremarkapp.c
  group Application/User/MBEDTLS/App
    ../MBEDTLS/App/: mbedtls.c net_sockets.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Middlewares/mbedTLS
    ../Middlewares/Third_Party/mbedTLS/library/: aes.c asn1parse.c asn1write.c base64.c bignum.c camellia.c certs.c chacha20.c chachapoly.c cipher.c cipher_wrap.c ctr_drbg.c debug.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c gcm.c hkdf.c md.c md5.c md_wrap.c memory_buffer_alloc.c oid.c pem.c pk.c pkparse.c pk_wrap.c platform.c platform_util.c poly1305.c rsa.c rsa_internal.c sha256.c sha512.c ssl_ciphersuites.c ssl_cli.c ssl_srv.c ssl_tls.c version_features.c x509.c x509_crt.c
    ../Middlewares/Third_Party/mbedTLS/include/: CMakeLists.txt
  group Utilities
    ../Utilities/3rdParty/MISC/: core_list_join.c core_main.c core_matrix.c core_state.c core_util.c core_portme.c
  group Library/ioLibrary_Driver
    ../Middlewares/Third_Party/ioLibrary_Driver/Ethernet/W5500/: w5500.c
    ../Middlewares/Third_Party/ioLibrary_Driver/Ethernet/: socket.c wizchip_conf.c
    ../Middlewares/Third_Party/ioLibrary_Driver/Internet/DHCP/: dhcp.c
software components: CMSIS:CORE 4.3.0
